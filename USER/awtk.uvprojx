# Keil uVision project awtk.uvprojx, settings and files
target awtk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: awtk +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,HAS_AWTK_CONFIG
  c misc: --gnu
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\KEY;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\MALLOC;..\USMART;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\HARDWARE\NAND;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\awtk;..\awtk\src;..\awtk\3rd;..\awtk\3rd\libunibreak;..\awtk\src\ext_widgets;..\awtk-port;..\awtk\3rd\nanovg\base;..\awtk\3rd\nanovg;..\awtk\3rd\agge
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_nand.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/NAND/: nand.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
  group AWTK
    ../awtk/src/base/: array.c bitmap.c buffer.c button.c canvas.c check_button.c color.c dialog.c easing.c edit.c emitter.c enums.c event_queue.c events.c font.c font_manager.c fs.c group_box.c idle.c image.c image_loader.c image_manager.c label.c layout.c lcd.c main_loop.c matrix.c mem.c progress_bar.c rect.c slider.c str.c system_info.c theme.c timer.c utf8.c utils.c value.c vgcanvas.c view.c widget.c widget_vtable.c window.c window_animator.c window_manager.c wstr.c widget_animator.c velocity.c glyph_cache.c widget_factory.c pages.c input_method.c tokenizer.c input_engine.c suggest_words.c spin_box.c dragger.c ui_builder.c dialog_client.c dialog_title.c custom_props.c button_group.c rom_fs.c tab_button.c tab_button_group.c tab_control.c color_parser.c combo_box.c combo_box_item.c line_break.c popup.c color_tile.c assets_manager.c locale_info.c path.c app_bar.c column.c grid.c row.c calibration_win.c font_loader.c window_base.c func_call_parser.c style.c style_const.c style_factory.c widget_animator_manager.c date_time.c time_now.c clip_board.c image_base.c widget_animator_factory_null.c
    ../awtk/src/blend/: stm32_g2d.c soft_g2d.c image_g2d.c blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgr565.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgba8888.c fill_image_bgr565.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgba8888.c rotate_image_bgr565.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgba8888.c
    ../awtk/src/lcd/: lcd_mem_rgb565.c lcd_mem_rgba8888.c lcd_mem_bgra8888.c lcd_mem_bgr565.c lcd_mem_bgr888.c
    ../awtk/src/ui_loader/: ui_builder_default.c ui_loader.c ui_loader_default.c ui_loader_xml.c ui_binary_writer.c ui_serializer.c ui_xml_writer.c window_open.c
    ../awtk/src/xml/: xml_builder.c xml_parser.c
    ../awtk/src/window_animators/: window_animator_fb.c
    ../awtk/src/main_loop/: main_loop_simple.c
    ../awtk/src/widget_animators/: widget_animator_move.c widget_animator_value.c widget_animator_opacity.c widget_animator_scroll.c widget_animator_factory.c widget_animator_rotation.c widget_animator_scale.c
    ../awtk/src/misc/: new.cpp
    ../awtk/src/image_loader/: image_loader_stb.c
    ../awtk/src/input_engines/: input_engine_null.c
    ../awtk/src/: awtk.c
    ../awtk/src/input_methods/: input_method_creator.c
    ../awtk/src/font_loader/: font_loader_bitmap.c font_loader_stb.c
    ../awtk/src/vgcanvas/: vgcanvas_nanovg_soft.c
    ../awtk/src/svg/: bsvg.c bsvg_builder.c bsvg_draw.c bsvg_to_svg.c svg_path.c svg_path_parser.c svg_shape.c svg_to_bsvg.c
    ../awtk/src/clip_board/: clip_board_default.c
    ../awtk/src/ext_widgets/guage/: guage_pointer.c
  group AWTK-PORT
    ../awtk-port/: main_loop_stm32_raw.c platform.c
    ../awtk/src/platforms/raw/: mutex_null.c fs_os.c
  group AWTK-DEMO
    ../awtk/demos/: demo_main.c assets.c demo_ui_app.c
  group LIBUNIBREAK
    ../awtk/3rd/libunibreak/: emojidef.c graphemebreak.c linebreak.c linebreakdata.c linebreakdef.c unibreakbase.c unibreakdef.c wordbreak.c
  group EXT_WIDGETS
    ../awtk/src/ext_widgets/rich_text/: rich_text.c rich_text_node.c rich_text_parser.c rich_text_render_node.c
    ../awtk/src/ext_widgets/: ext_widgets.c
    ../awtk/src/ext_widgets/color_picker/: color_component.c color_picker.c rgb_and_hsv.c
    ../awtk/src/ext_widgets/keyboard/: candidates.c keyboard.c
    ../awtk/src/ext_widgets/scroll_view/: list_item.c list_view.c list_view_h.c scroll_bar.c scroll_view.c
    ../awtk/src/ext_widgets/slide_view/: slide_view.c
    ../awtk/src/ext_widgets/time_clock/: time_clock.c digit_clock.c
    ../awtk/src/ext_widgets/guage/: guage.c
    ../awtk/src/ext_widgets/text_selector/: text_selector.c
    ../awtk/src/ext_widgets/switch/: switch.c
    ../awtk/src/ext_widgets/image_animation/: image_animation.c
    ../awtk/src/ext_widgets/progress_circle/: progress_circle.c
  group NANOVG
    ../awtk/3rd/nanovg/base/: nanovg.c
  group AGGE
    ../awtk/3rd/agge/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
    ../awtk/3rd/nanovg/agge/: nanovg_agge.cpp nanovg_vertex.cpp
